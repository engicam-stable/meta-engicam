FILESEXTRAPATHS_prepend := "${THISDIR}/busybox-1.21.1:"
SRC_URI += "file://defconfig"


