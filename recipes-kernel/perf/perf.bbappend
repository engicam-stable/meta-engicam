
EXTRA_OEMAKE_remove = 'EXTRA_CFLAGS="-ldw"'