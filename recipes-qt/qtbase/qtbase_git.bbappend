FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://1001-fix-qtbug-55629.patch"
